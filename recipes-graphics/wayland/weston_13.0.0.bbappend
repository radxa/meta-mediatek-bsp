FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-HACK-mediatek-weston-add-clear-mode-flow-for-hotplug.patch"

