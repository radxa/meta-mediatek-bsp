LIBCAMERA_PIPELINES ??= "uvcvideo,simple"
PACKAGECONFIG:append = " gst"
