FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-device-Fix-Pair-method-not-setting-auto-connect.patch \
"

