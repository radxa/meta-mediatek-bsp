FILESEXTRAPATHS:prepend:mt8365-evk := "${THISDIR}/mt8365-evk:"
FILESEXTRAPATHS:prepend:genio-700-evk := "${THISDIR}/mt8390-evk:"
FILESEXTRAPATHS:prepend:genio-1200-evk := "${THISDIR}/mt8395-evk:"
FILESEXTRAPATHS:prepend:genio-510-evk := "${THISDIR}/mt8370-evk:"
FILESEXTRAPATHS:prepend:genio-720-evk := "${THISDIR}/mt8391-evk:"
