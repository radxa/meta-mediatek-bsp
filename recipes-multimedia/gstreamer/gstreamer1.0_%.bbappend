FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-gst-launch-accept-option-to-set-program-name.patch \
"
