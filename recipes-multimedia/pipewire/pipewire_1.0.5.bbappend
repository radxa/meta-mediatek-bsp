PACKAGECONFIG:class-target:append = " bluez-lc3 "
